## lib/One/linux-one/src/Kconfig
```kconfig
config LINUX_ONE
	tristate "Linux One IPC"
	---help---
	  Linux One is the new IPC API used by Coma
```
